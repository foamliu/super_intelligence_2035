MACRO INVD8BWP40P140LVT
  CLASS CORE ;
  SIZE 0.48 BY 1.44 ;
  SYMMETRY X Y R90 ;
  SITE coreSite ;
END INVD8BWP40P140LVT
MACRO INVD16BWP40P140LVT
  CLASS CORE ;
  SIZE 0.96 BY 1.44 ;
  SYMMETRY X Y R90 ;
  SITE coreSite_v2 ;
END INVD16BWP40P140LVT
SITE coreSite
  SIZE 0.24 BY 1.44 ;
  SYMMETRY Y ;
END coreSite
SITE coreSite_v2
  SIZE 0.24 BY 2.88 ;
  SYMMETRY Y ;
END coreSite_v2
